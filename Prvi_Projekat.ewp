# IAR project Prvi_Projekat.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX
  ICCARM.CCIncludePath2: Libraries; $PROJ_DIR$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Prvi_Projekat.bin
  ILINK.IlinkOutputFile: Prvi_Projekat.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    Include/STM32F4-Discovery/: stm32f4_discovery.h stm32f4_discovery_audio_codec.h stm32f4_discovery_lis302dl.h
    ./: stm32f4xx_conf.h
  group EWARM
    Include/EWARM/: startup_stm32f4xx.s
  group STM32F4-Discovery
    Include/STM32F4-Discovery/: stm32f4_discovery.c
  group STM32F4xx_StdPeriph_Driver
    Include/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c
  group User
    ./: main.c system_stm32f4xx.c VoltageRegulator.c
